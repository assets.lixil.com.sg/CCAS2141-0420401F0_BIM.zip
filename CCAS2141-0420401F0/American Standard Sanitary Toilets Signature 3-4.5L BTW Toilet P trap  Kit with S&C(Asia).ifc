Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2021-09-30T16:28:03
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190108_1515(x64) - Exporter 19.2.1.1 - Alternate UI 19.2.1.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Sep 30 16:28:03 2021 * Host: DESKTOP-OPR7GPE * Database: C:\Users\ABLESU~1\AppData\Local\Temp\{47376EF6-5768-4331-836A-F0907D2E8394}\ifc * Database version: 5507 * Database creation date: Thu Sep 30 16:28:02 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Sep 30 16:28:02 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Sep 30 16:28:02 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 12, 46, 799999; RefLongitude: -71, -1, -58, -799999; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcFlowTerminal: 3/4.5L BTW Toilet P trap Kit with S&C(Asia) CCAS2141-0420401F0, American Standard Sanitary Toilets Signature 3-4.5L BTW Toilet P trap Kit with S&C(Asia):3/4.5L BTW Toilet P trap Kit with S&C(Asia) CCAS2141-0420401F0:917633
In: Level 1
Material: Plastic_White, Ceramic_White
Pset_ManufacturerTypeInformation - Manufacturer: American Standard
Pset_DistributionFlowElementCommon - Reference: 3/4.5L BTW Toilet P trap Kit with S&C(Asia) CCAS2141-0420401F0
